# EVerest variable defaults

EVEREST_VERSION_FILE ?= "${sysconfdir}/everest/everest_version"
EVEREST_RELEASE_FILE ?= "${sysconfdir}/everest/everest_release.json"
EVEREST_RELEASE_PACKAGES ?= ""
