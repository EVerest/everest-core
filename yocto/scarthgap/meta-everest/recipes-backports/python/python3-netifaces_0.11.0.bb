SUMMARY = "netifaces: Portable network interface information."

HOMEPAGE = "https://github.com/al45tair/netifaces"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e4677613c25bf3673bfee98c0cc52202"

SRC_URI[sha256sum] = "043a79146eb2907edf439899f262b3dfe41717d34124298ed281139a8b93ca32"

PYPI_PACKAGE = "netifaces"

inherit pypi setuptools3
