SRCREV = "28b78822cfc5fbec4bd9906168493e9985f586ed"
PV = "v2.2.1"
SRC_URI = "git://github.com/Kistler-Group/sdbus-cpp.git;protocol=https;branch=master"
