# generated by running:
# devtool add https://github.com/EVerest/everest-admin-panel.git --srcbranch main --srcrev 2ff6acd659ea0ce012e42e02d73819130484081f
LICENSE = "0BSD & Apache-2.0 & BSD-2-Clause & BSD-3-Clause & ISC & MIT & Python-2.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10 \
                    file://node_modules/@babel/helper-string-parser/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
                    file://node_modules/@babel/helper-validator-identifier/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
                    file://node_modules/@babel/parser/LICENSE;md5=3b324af8e79986f4a5621efa85dd1292 \
                    file://node_modules/@babel/types/LICENSE;md5=b1d0cd283a346e919abb3beeb018279d \
                    file://node_modules/@fontsource/roboto/LICENSE;md5=4538a5afdd18ccebd224405ffe3dee4b \
                    file://node_modules/@highlightjs/vue-plugin/LICENSE;md5=6b77a8a192fe40f7cc1e606f8a7ba5f1 \
                    file://node_modules/@jridgewell/sourcemap-codec/LICENSE;md5=2327dcc62ba928de8438ea5881779911 \
                    file://node_modules/@json-layout/core/LICENSE;md5=0095eb1c730fab6cfb3b7403284599d5 \
                    file://node_modules/@json-layout/vocabulary/LICENSE;md5=0095eb1c730fab6cfb3b7403284599d5 \
                    file://node_modules/@koumoul/vjsf/LICENSE;md5=0cf31bb9e2152bcb0ec2adeefcec6469 \
                    file://node_modules/@mdi/font/LICENSE;md5=7f104afa30591ec383c5140124c88aef \
                    file://node_modules/@rollup/plugin-commonjs/LICENSE;md5=62156287ac5c93a99f7e0d75ad31c2bf \
                    file://node_modules/@rollup/pluginutils/LICENSE;md5=62156287ac5c93a99f7e0d75ad31c2bf \
                    file://node_modules/@types/estree/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/@types/web-bluetooth/LICENSE;md5=d4a904ca135bb7bc912156fee12726f0 \
                    file://node_modules/@volar/language-core/LICENSE;md5=b25e97aa2558823429bb828fba3f9214 \
                    file://node_modules/@volar/source-map/LICENSE;md5=b25e97aa2558823429bb828fba3f9214 \
                    file://node_modules/@volar/typescript/LICENSE;md5=b25e97aa2558823429bb828fba3f9214 \
                    file://node_modules/@vue/compat/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/compiler-core/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/compiler-dom/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/compiler-sfc/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/compiler-ssr/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/devtools-api/LICENSE;md5=f30c009ef471e17b47739dca600a2cbe \
                    file://node_modules/@vue/devtools-kit/LICENSE;md5=f30c009ef471e17b47739dca600a2cbe \
                    file://node_modules/@vue/devtools-shared/LICENSE;md5=f30c009ef471e17b47739dca600a2cbe \
                    file://node_modules/@vue/language-core/LICENSE;md5=b25e97aa2558823429bb828fba3f9214 \
                    file://node_modules/@vue/reactivity/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/runtime-core/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/runtime-dom/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/server-renderer/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vue/shared/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/@vuetify/loader-shared/LICENSE.md;md5=3d04e7a36a8858d05f40edddf7274277 \
                    file://node_modules/@vueuse/core/LICENSE;md5=558512d335cce23b3acb71df7f617cc9 \
                    file://node_modules/@vueuse/metadata/LICENSE;md5=558512d335cce23b3acb71df7f617cc9 \
                    file://node_modules/@vueuse/shared/LICENSE;md5=558512d335cce23b3acb71df7f617cc9 \
                    file://node_modules/ajv-errors/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/ajv-formats/LICENSE;md5=b070047241b584db26163b1dca5206e0 \
                    file://node_modules/ajv-i18n/LICENSE;md5=715855234c57d97032971adfc0608a07 \
                    file://node_modules/ajv/LICENSE;md5=5ed8db7ae36f56c8a5cfc218c41ac926 \
                    file://node_modules/alien-signals/LICENSE;md5=4d0d0533cba31e78ea07b01ade7110e8 \
                    file://node_modules/argparse/LICENSE;md5=203a6dbc802ee896020a47161e759642 \
                    file://node_modules/birpc/LICENSE;md5=587b0e4da9c8439672969292e626aab4 \
                    file://node_modules/commondir/LICENSE;md5=31f6d70a3b756797901b2aff55cc7d7a \
                    file://node_modules/copy-anything/LICENSE;md5=29b832549f2b317a09ec1e820eb324d9 \
                    file://node_modules/csstype/LICENSE;md5=e71640b3d80aa47c69967e588c744bfb \
                    file://node_modules/debug/LICENSE;md5=d85a365580888e9ee0a01fb53e8e9bf0 \
                    file://node_modules/entities/LICENSE;md5=d5b9cb3bc7f6ffd7bea8661f30447c11 \
                    file://node_modules/esbuild/LICENSE.md;md5=46b907b175628fe6d2a5258b252970fa \
                    file://node_modules/estree-walker/LICENSE;md5=535713f6259158ff4b0d63de5da7f078 \
                    file://node_modules/fast-deep-equal/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/fast-uri/LICENSE;md5=4428cb35f8d8607870e0c204e26e9f76 \
                    file://node_modules/fdir/LICENSE;md5=7d4b8f322c8f08cad3cb115882559ed2 \
                    file://node_modules/highlight.js/LICENSE;md5=1536cfb4c71fcc69423296231a64c1c4 \
                    file://node_modules/hookable/LICENSE.md;md5=89741feb4273d1b7d930d2619e47856c \
                    file://node_modules/immer/LICENSE;md5=31f7d36ee7fe711a4628d22f779fc5ef \
                    file://node_modules/is-what/LICENSE;md5=29b832549f2b317a09ec1e820eb324d9 \
                    file://node_modules/js-yaml/LICENSE;md5=effd621a9bf5d72d6a7e6ef819bf3afb \
                    file://node_modules/json-schema-traverse/LICENSE;md5=ea87ade09b9e6da4f2e47904a4ee137b \
                    file://node_modules/just-clone/LICENSE;md5=9a101e543aed27cd8558f6376292442e \
                    file://node_modules/konva/LICENSE;md5=164b7922ad16f823f27788d36136a44b \
                    file://node_modules/magic-string/LICENSE;md5=17b8fdc59ea5ccf4488260421093f766 \
                    file://node_modules/magicast/LICENSE;md5=b4c5d677d375a378ad97f463accfbce2 \
                    file://node_modules/marked/LICENSE.md;md5=63067ac27c0f658572e4798649c2ef4a \
                    file://node_modules/mitt/LICENSE;md5=4ed316158806c1e39b6b6e457c85b10f \
                    file://node_modules/ms/license.md;md5=2b8bc52ae6b7ba58e1629deabd53986f \
                    file://node_modules/muggle-string/LICENSE;md5=26be18faa64ebb63b4f84a5aa55da53c \
                    file://node_modules/nanoid/LICENSE;md5=237c21016e56a1ee4475a39fc00d1504 \
                    file://node_modules/notyf/LICENSE.md;md5=ce2fd27755b03c15b9a2faf59d4cb062 \
                    file://node_modules/path-browserify/LICENSE;md5=17b15c42072231f9ebd9f287fc7793fc \
                    file://node_modules/perfect-debounce/LICENSE;md5=acc13761f32b1345cfb5f817b0c140c0 \
                    file://node_modules/picocolors/LICENSE;md5=efe274148be031a1fbdaf790e245552b \
                    file://node_modules/picomatch/LICENSE;md5=abd0e25891525eb13d5a794f550a6ee4 \
                    file://node_modules/pinia/LICENSE;md5=c6972b63f41e7aa5567e73d7c133fd47 \
                    file://node_modules/postcss/LICENSE;md5=e0ef868fdaaba6859dcbab082c20439b \
                    file://node_modules/require-from-string/license;md5=be72c3ad86c1c4e9578a1945b082b17d \
                    file://node_modules/rfdc/LICENSE;md5=fc2ea1f4c58a804909742c8eadede5ea \
                    file://node_modules/rollup/LICENSE.md;md5=fffea8d009f83851ad9ae5e568e553f2 \
                    file://node_modules/source-map-js/LICENSE;md5=b1ca6dbc0075d56cbd9931a75566cd44 \
                    file://node_modules/speakingurl/LICENSE;md5=47c8fd5bc11011b6ae35dd056b953b59 \
                    file://node_modules/splitpanes/LICENSE;md5=9908168fcd63d59c0294fc0716f0589d \
                    file://node_modules/superjson/LICENSE;md5=18ce925a0bdce9641701aa9adcbcd931 \
                    file://node_modules/tinyglobby/LICENSE;md5=3d2948034972f6f7dcef52745be90242 \
                    file://node_modules/typescript/LICENSE.txt;md5=55a8748c7d5c7253f3e4bb7402ff04db \
                    file://node_modules/upath/LICENSE;md5=f951d50f8950cef986e18e428fd8fcc7 \
                    file://node_modules/vee-validate/LICENSE;md5=776e453114b988e720953109d13f1ba1 \
                    file://node_modules/vee-validate/node_modules/type-fest/license-cc0;md5=65d3616852dbf7b1a6d4b53b00626032 \
                    file://node_modules/vee-validate/node_modules/type-fest/license-mit;md5=d5f2a6dd0192dcc7c833e50bb9017337 \
                    file://node_modules/vite-plugin-vuetify/LICENSE.md;md5=3d04e7a36a8858d05f40edddf7274277 \
                    file://node_modules/vite/LICENSE.md;md5=f3a75bb4d4149391bf68849f2abca574 \
                    file://node_modules/vscode-uri/LICENSE.md;md5=3f8a83a05bc59c7a6122980df91bdd1c \
                    file://node_modules/vue-router/LICENSE;md5=c6972b63f41e7aa5567e73d7c133fd47 \
                    file://node_modules/vue-tsc/LICENSE;md5=b25e97aa2558823429bb828fba3f9214 \
                    file://node_modules/vue/LICENSE;md5=80753afcd3540ce1f845ee2cc8f33114 \
                    file://node_modules/vuetify/LICENSE.md;md5=cbf90306802a40594aa8c291a6f8486f \
                    file://node_modules/@fontsource/open-sans-condensed/README.md;md5=ae5614fcc5f29064642a61582e030c9c \
                    file://node_modules/is-reference/README.md;md5=1ae863bf798164adb824f7ec768eb094"

SRC_URI = "https://github.com/EVerest/everest-admin-panel/releases/download/v0.5.1/everest-admin-panel.tar.gz;subdir=${S}/everest-admin-panel \
           npmsw://${THISDIR}/${BPN}/npm-shrinkwrap.json \
          "
SRC_URI[sha256sum] = "7b5817aff5979c28647d754f9500809fb8d8125957a7716fcf1e8d856450f8da"

FILES:${PN} += "${datadir}/everest/www/*"

do_install() {
    install -d ${D}/usr/share/everest/www
    cp -a --no-preserve=ownership ${S}/everest-admin-panel/* ${D}/usr/share/everest/www/
}

INSANE_SKIP:${PN} += "file-rdeps"

LICENSE:${PN} = "Apache-2.0"
LICENSE:${PN}-babel-helper-string-parser = "MIT"
LICENSE:${PN}-babel-helper-validator-identifier = "MIT"
LICENSE:${PN}-babel-parser = "MIT"
LICENSE:${PN}-babel-types = "MIT"
LICENSE:${PN}-fontsource-open-sans-condensed = "MIT"
LICENSE:${PN}-fontsource-roboto = "Apache-2.0"
LICENSE:${PN}-highlightjs-vue-plugin = "BSD-3-Clause"
LICENSE:${PN}-jridgewell-sourcemap-codec = "MIT"
LICENSE:${PN}-json-layout-core = "MIT"
LICENSE:${PN}-json-layout-vocabulary = "MIT"
LICENSE:${PN}-koumoul-vjsf = "MIT"
LICENSE:${PN}-mdi-font = "Apache-2.0"
LICENSE:${PN}-rollup-plugin-commonjs = "MIT"
LICENSE:${PN}-rollup-pluginutils = "MIT"
LICENSE:${PN}-types-estree = "MIT"
LICENSE:${PN}-types-web-bluetooth = "MIT"
LICENSE:${PN}-volar-language-core = "MIT"
LICENSE:${PN}-volar-source-map = "MIT"
LICENSE:${PN}-volar-typescript = "MIT"
LICENSE:${PN}-vue-compat = "MIT"
LICENSE:${PN}-vue-compiler-core = "MIT"
LICENSE:${PN}-vue-compiler-dom = "MIT"
LICENSE:${PN}-vue-compiler-sfc = "MIT"
LICENSE:${PN}-vue-compiler-ssr = "MIT"
LICENSE:${PN}-vue-devtools-api = "MIT"
LICENSE:${PN}-vue-devtools-kit = "MIT"
LICENSE:${PN}-vue-devtools-shared = "MIT"
LICENSE:${PN}-vue-language-core = "MIT"
LICENSE:${PN}-vue-reactivity = "MIT"
LICENSE:${PN}-vue-runtime-core = "MIT"
LICENSE:${PN}-vue-runtime-dom = "MIT"
LICENSE:${PN}-vue-server-renderer = "MIT"
LICENSE:${PN}-vue-shared = "MIT"
LICENSE:${PN}-vuetify-loader-shared = "MIT"
LICENSE:${PN}-vueuse-core = "MIT"
LICENSE:${PN}-vueuse-metadata = "MIT"
LICENSE:${PN}-vueuse-shared = "MIT"
LICENSE:${PN}-ajv = "MIT"
LICENSE:${PN}-ajv-errors = "MIT"
LICENSE:${PN}-ajv-formats = "MIT"
LICENSE:${PN}-ajv-i18n = "MIT"
LICENSE:${PN}-alien-signals = "MIT"
LICENSE:${PN}-argparse = "Python-2.0"
LICENSE:${PN}-birpc = "MIT"
LICENSE:${PN}-commondir = "MIT"
LICENSE:${PN}-copy-anything = "MIT"
LICENSE:${PN}-csstype = "MIT"
LICENSE:${PN}-debug = "MIT"
LICENSE:${PN}-entities = "BSD-2-Clause"
LICENSE:${PN}-esbuild = "MIT"
LICENSE:${PN}-estree-walker = "MIT"
LICENSE:${PN}-fast-deep-equal = "MIT"
LICENSE:${PN}-fast-uri = "BSD-3-Clause"
LICENSE:${PN}-fdir = "MIT"
LICENSE:${PN}-highlightjs = "BSD-3-Clause"
LICENSE:${PN}-hookable = "MIT"
LICENSE:${PN}-immer = "MIT"
LICENSE:${PN}-is-reference = "MIT"
LICENSE:${PN}-is-what = "MIT"
LICENSE:${PN}-js-yaml = "MIT"
LICENSE:${PN}-json-schema-traverse = "MIT"
LICENSE:${PN}-just-clone = "MIT"
LICENSE:${PN}-konva = "MIT"
LICENSE:${PN}-magic-string = "MIT"
LICENSE:${PN}-magicast = "MIT"
LICENSE:${PN}-marked = "MIT"
LICENSE:${PN}-mitt = "MIT"
LICENSE:${PN}-ms = "MIT"
LICENSE:${PN}-muggle-string = "MIT"
LICENSE:${PN}-nanoid = "MIT"
LICENSE:${PN}-notyf = "MIT"
LICENSE:${PN}-path-browserify = "MIT"
LICENSE:${PN}-perfect-debounce = "MIT"
LICENSE:${PN}-picocolors = "ISC"
LICENSE:${PN}-picomatch = "MIT"
LICENSE:${PN}-pinia = "MIT"
LICENSE:${PN}-postcss = "MIT"
LICENSE:${PN}-require-from-string = "MIT"
LICENSE:${PN}-rfdc = "MIT"
LICENSE:${PN}-rollup = "MIT"
LICENSE:${PN}-source-map-js = "BSD-3-Clause"
LICENSE:${PN}-speakingurl = "BSD-3-Clause"
LICENSE:${PN}-splitpanes = "MIT"
LICENSE:${PN}-superjson = "MIT"
LICENSE:${PN}-tinyglobby = "MIT"
LICENSE:${PN}-typescript = "Apache-2.0"
LICENSE:${PN}-upath = "MIT"
LICENSE:${PN}-vee-validate = "MIT"
LICENSE:${PN}-vee-validate-type-fest = "MIT | CC0-1.0"
LICENSE:${PN}-vite = "MIT"
LICENSE:${PN}-vite-plugin-vuetify = "MIT"
LICENSE:${PN}-vscode-uri = "MIT"
LICENSE:${PN}-vue = "MIT"
LICENSE:${PN}-vue-router = "MIT"
LICENSE:${PN}-vue-router-vue-devtools-api = "MIT"
LICENSE:${PN}-vue-tsc = "MIT"
LICENSE:${PN}-vuetify = "MIT"
