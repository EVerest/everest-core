LICENSE = "Apache-2.0"

# libslac moved to everest-core, this recipe is kept for compatibility
ALLOW_EMPTY:${PN} = "1"
