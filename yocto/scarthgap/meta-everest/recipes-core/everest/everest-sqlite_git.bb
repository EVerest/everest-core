LICENSE = "Apache-2.0"

# everest-sqlite moved to EVerest, this recipe is kept for compatibility
ALLOW_EMPTY:${PN} = "1"
