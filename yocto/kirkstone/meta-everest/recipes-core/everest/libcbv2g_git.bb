LICENSE = "Apache-2.0"

# libcbv2g moved to EVerest, this recipe is kept for compatibility
ALLOW_EMPTY:${PN} = "1"
